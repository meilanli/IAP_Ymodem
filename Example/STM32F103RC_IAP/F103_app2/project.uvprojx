# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./app1.bin ./Objects/project.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\APP;.\APP\include;.\driver\include;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\CMSIS\CM3\CoreSupport;.\iap
  library: MicroLIB
  memory RVCT4: ROM 0x8002800 size 0xd800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./APP/: main.c stm32f10x_it.c delay.c
    ./APP/include/: config.h
  group iap
    ./iap/: iap_app.c
  group driver
    ./driver/: flash.c io.c
  group libraries
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_ld.s
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
